# Keil uVision project offline_programmer.uvprojx, settings and files
target frdmk64_offline_programmer (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sdcard_fatfs.out +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CPU_MK64FN1M0VMD12
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MK64F12/drivers;../../../../../middleware/fatfs_0.11a/src;../../../../../middleware/fatfs_0.11a/src/fsl_sd_disk;..;../../../../../devices/MK64F12/utilities;../../../../../middleware/sdmmc_2.0.0/inc;../../../../../middleware/sdmmc_2.0.0/src;../../..;../../../../../devices/MK64F12;..\swd;..\flash_algorithm
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.s
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_sdhc.h fsl_sdhc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c fsl_ftm.c fsl_ftm.h fsl_pit.c fsl_pit.h
  group source
    ../: sdcard_fatfs.c sdhc_config.h event.c ffconf.h
  group FATFS_Source
    ../../../../../middleware/fatfs_0.11a/src/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
    ../../../../../middleware/fatfs_0.11a/src/: integer.h ff.c ff.h diskio.c diskio.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdmmc-src
    ../../../../../middleware/sdmmc_2.0.0/src/: fsl_sd.c fsl_mmc.c fsl_sdmmc.c
  group sdmmc-inc
    ../../../../../middleware/sdmmc_2.0.0/inc/: fsl_card.h fsl_specification.h fsl_sdmmc.h
  group swd
    ../swd/: swd.c swd_pin.c
  group flash_algorithm
    ../flash_algorithm/: flash_kientis.c flash_kinetis_algorithm.c flash_kinetis_eep_algorithm.c
